options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2412000000'
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: '0.75'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'False'
    file: /home/pi/recording_2502.txt
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/wifi.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/joel/kDrive/ETHZ/Semester_Project/GnuRadio/gr-ieee802-11/examples/recordings/wifi_iq_only_20250218_short.txt
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    log_level: trace
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"wifi_toa"'
    name: wifi toa
    type: complex
    vlen: '64'
  states: {state: disabled}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"wifi_toa"'
    name: wifi toa (frame equalizer)
    type: byte
    vlen: '64'
  states: {state: disabled}
- name: blocks_tag_debug_0_1
  id: blocks_tag_debug
  parameters:
    filter: '"rx_time"'
    name: rx_time
    type: complex
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    filter: '"sample_counter"'
    name: sample counter
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import socket
      import struct
      import pmt
      import time
      import numpy as np
      from gnuradio import gr

      class UDPTagSender(gr.basic_block):
          def __init__(self, udp_ip="127.0.0.1", udp_port=5005):
              gr.basic_block.__init__(self,
                  name="UDP Tag Sender",
                  in_sig=[(np.complex64, 1)],  # Assuming complex samples
                  out_sig=None)
              
              self.udp_ip = udp_ip
              self.udp_port = udp_port
              self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              self.mac_address = "00:11:22:33:44:55"  # Replace with actual MAC

          def general_work(self, input_items, output_items):
              nread = self.nitems_read(0)  # Get the starting sample index
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tags:
                  key = pmt.to_python(tag.key) # convert from PMT to python string
                  value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                  print(f"key: {key}")
                  print(f"value: {value} as {type(value)}")
                   
              timestamp = time.time()  # Dummy timestamp (current time)
              mac_address = bytes.fromhex("001122334455")  # Dummy MAC address (6 bytes)
              
              packet_data = struct.pack("!d6s", timestamp, mac_address)  # 8 bytes timestamp + 6 bytes MAC
              
              self.sock.sendto(packet_data, (self.udp_ip, self.udp_port))

              self.consume(0, len(input_items[0]))  # Consume all samples
              return 0
    udp_ip: '''127.0.0.1'''
    udp_port: '5005'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import socket
      from gnuradio import gr

      class udp_sender(gr.basic_block):
          def __init__(self, host="127.0.0.1", port=5005, node_id=0):
              gr.basic_block.__init__(self,
                  name="udp_sender",
                  in_sig=None,   # No regular input signal, only messages
                  out_sig=None)

              self.host = host
              self.port = port
              self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              self.node_id = node_id

              # Register message input port
              self.message_port_register_in(gr.pmt.intern("in"))
              self.set_msg_handler(gr.pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              """Handles incoming messages and sends them over UDP."""
              # template dict with dummy values
              msg_dict = {"node": "","wifi_toa": 0.0, "address 3": "", "address 2": "", "address 1": "", "sequence number": "", "ssid": "", "subtype": "", "type": "", "duration": "", "dlt": "", "frame bytes": "", "encoding": "", "snr": "", "nominal frequency": "", "frequency offset": "", "beta": "", "csi": []}
              msg_dict["node"] = self.node_id
              
              try:
                  print("=+===========================================================")
                  
                  # Send the serialized message over UDP
                  msg_str = str.split(str(msg), ") (")
                  remove_chars = ["(", ")", "#", "[", "]", "'"]
                  for c in remove_chars:
                      msg_str = [m.replace(c, "") for m in msg_str]
                      # print(f"Message: {msg_str}")
                  for m in msg_str:
                      tmp = m.split(" . ")
                      # print(f"Tmp: {tmp}")
                      if len(tmp) > 1:
                          try:
                              msg_dict[tmp[0]] = tmp[1]
                              print(f"Key: {tmp[0]}, Value: {tmp[1]}")
                          except:
                              print(f"Error parsing message: {tmp}")
                              pass

                      
                  self.sock.sendto(str(msg_dict).encode('utf-8'), (self.host, self.port))
              except Exception as e:
                  print(f"Error sending UDP message: {e}")

      if __name__ == "__main__":
          # Create the UDP sender block
          sender = udp_sender(host="127.0.0.1", port=5005)
          message = "((address 3 . 48:2c:d0:3c:db:82) (address 2 . 48:2c:d0:3c:db:82) (address 1 . ff:ff:ff:ff:ff:ff) (sequence number . 212) (ssid . eduroam) (subtype . Beacon) (type . management) (duration . 0) (dlt . 105) (frame bytes . 370) (encoding . 0) (snr . 18.5551) (nominal frequency . 2.412e+09) (frequency offset . -21147.7) (beta . 0.907213) (csi . #[(0.566118,-0.298401) (0.631518,-0.245726) (0.657571,-0.144538) (0.690639,0.0103949) (0.678849,0.072456) (0.680707,0.0461684) (0.591707,0.162084) (0.478976,0.212965) (0.451279,0.239542) (0.387056,0.253145) (0.250386,0.159893) (0.191558,0.107284) (0.171853,0.118913) (0.0702613,-0.0185443) (0.109905,-0.146988) (0.0742382,-0.270683) (0.165585,-0.379584) (0.168831,-0.497667) (0.354727,-0.591889) (0.437455,-0.557083) (0.570716,-0.612538) (0.77234,-0.635723) (0.912641,-0.598075) (0.93393,-0.483502) (1.00211,-0.349984) (1.08942,-0.176415) (0.943632,0.156554) (0.82913,0.334521) (0.568084,0.285006) (0.462272,0.267365) (0.253101,0.193681) (0.109876,0.0587345) (0.087862,-0.102265) (0.031854,-0.287846) (0.198047,-0.43826) (0.38686,-0.529481) (0.521877,-0.604409) (0.747475,-0.603303) (0.99424,-0.58217) (1.12874,-0.440593) (1.28294,-0.222313) (1.36439,0.0103244) (1.27361,0.252473) (1.2032,0.410093) (1.0735,0.546541) (0.885395,0.565614) (0.754109,0.613179) (0.580458,0.516457) (0.556105,0.360515) (0.411728,0.209677) (0.452793,0.0442217) (0.580392,-0.111653)]) (wifi_toa . 0.297104))"
          sender.handle_msg(message)
    host: udp_ip_address
    node_id: '0'
    port: udp_port
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import pmt
      import numpy as np
      from gnuradio import gr

      import datetime



      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, format_timestamp=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Print DroneID Packets',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.format_timestamp = int(format_timestamp)
              self.message_port_register_in(gr.pmt.intern("in"))
              self.set_msg_handler(gr.pmt.intern("in"), self.handle_msg)
              self.id = 0
              
          def handle_msg(self, msg):
              msg = pmt.to_python(msg)
              try:
                  mac_tx = [msg[0]['address 2'], msg[0]['address 1'], msg[0]['address 3']]
                  if "e8:94:f6:09:ae:bd" in mac_tx:
                      if self.format_timestamp == 1:
                          timestamp = msg[0]['wifi_toa']
                          seconds = int(timestamp)  # Extract seconds
                          nanoseconds = int((timestamp - seconds) * 1e9)  # Extract nanoseconds

                          formatted_time = f"{datetime.datetime.utcfromtimestamp(seconds).strftime('%Y-%m-%d %H:%M:%S')}.{nanoseconds:09d}"
                          # timestamp = msg[0]['wifi_toa']
                          # dt = datetime.datetime.utcfromtimestamp(timestamp)
                          # formatted_time = dt.strftime('%Y-%m-%d %H:%M:%S.%f')  # Microseconds included

                          print(f"[{self.id}] DroneID Packet found: {formatted_time} - {msg[1]} {mac_tx}")
                      else:
                          print (f"[{self.id}] DroneID Packet found: {msg[0]['wifi_toa']:.9f} - {msg[1]} {mac_tx}")
                      self.id = self.id + 1
              except:
                  pass
    format_timestamp: '1'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {state: disabled}
- name: freq
  id: parameter
  parameters:
    label: Center frequency
    short_id: f
    type: intx
    value: '2412000000'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: node
  id: parameter
  parameters:
    label: ID of receiver node
    short_id: n
    type: intx
    value: '0'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 48*10
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: udp_ip_address
  id: parameter
  parameters:
    label: IP address of udp receiver
    short_id: a
    type: str
    value: 127.0.0.1
  states: {}
- name: udp_port
  id: parameter
  parameters:
    label: Port of udp receiver
    short_id: p
    type: intx
    value: '5005'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_source0: gpsdo
    dev_addr: ''
    dev_args: '""'
    gain0: gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: gps_time
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_meta_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_tag_debug_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', blocks_tag_debug_0_0, '0']
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_11_parse_mac_0, out, blocks_message_debug_0, print]
- [ieee802_11_parse_mac_0, out, epy_block_1, in]
- [ieee802_11_parse_mac_0, out, epy_block_2, in]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_long_0, '0', epy_block_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_tag_debug_1, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_tag_debug_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
