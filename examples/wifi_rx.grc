options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2412000000'
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: '0.75'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'False'
    file: /home/pi/recording_2502.txt
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/wifi.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/joel/kDrive/ETHZ/Semester_Project/GnuRadio/gr-ieee802-11/examples/recordings/wifi_iq_only_20250218_short.txt
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    log_level: trace
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"wifi_toa"'
    name: wifi toa
    type: complex
    vlen: '64'
  states: {state: disabled}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"wifi_toa"'
    name: wifi toa (frame equalizer)
    type: byte
    vlen: '64'
  states: {state: disabled}
- name: blocks_tag_debug_0_1
  id: blocks_tag_debug
  parameters:
    display: 'False'
    filter: '"rx_time"'
    name: rx_time
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    filter: '"wifi_toa"'
    name: wifi toa
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import socket
      import struct
      import pmt
      import time
      import numpy as np
      from gnuradio import gr

      class UDPTagSender(gr.basic_block):
          def __init__(self, udp_ip="127.0.0.1", udp_port=5005):
              gr.basic_block.__init__(self,
                  name="UDP Tag Sender",
                  in_sig=[(np.complex64, 1)],  # Assuming complex samples
                  out_sig=None)
              
              self.udp_ip = udp_ip
              self.udp_port = udp_port
              self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              self.mac_address = "00:11:22:33:44:55"  # Replace with actual MAC

          def general_work(self, input_items, output_items):
              nread = self.nitems_read(0)  # Get the starting sample index
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tags:
                  key = pmt.to_python(tag.key) # convert from PMT to python string
                  value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                  print(f"key: {key}")
                  print(f"value: {value} as {type(value)}")
                   
              timestamp = time.time()  # Dummy timestamp (current time)
              mac_address = bytes.fromhex("001122334455")  # Dummy MAC address (6 bytes)
              
              packet_data = struct.pack("!d6s", timestamp, mac_address)  # 8 bytes timestamp + 6 bytes MAC
              
              self.sock.sendto(packet_data, (self.udp_ip, self.udp_port))

              self.consume(0, len(input_items[0]))  # Consume all samples
              return 0
    udp_ip: '''127.0.0.1'''
    udp_port: '5005'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import socket
      import pmt
      import datetime
      from gnuradio import gr

      msg_template_dict = {"node": "", "wifi_toa": 0.0, "address 3": "", "address 2": "", "address 1": "", "sequence number": "", "ssid": "", "subtype": "", "type": "", "duration": "", "dlt": "", "frame bytes": "", "encoding": "", "snr": "", "nominal frequency": "", "frequency offset": "", "beta": "", "csi": []}


      class udp_sender(gr.basic_block):
          def __init__(self, host="127.0.0.1", port=5005, node_id=0):
              gr.basic_block.__init__(self,
                  name="udp_sender",
                  in_sig=None,   # No regular input signal, only messages
                  out_sig=None)

              self.host = host
              self.port = port
              self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              self.node_id = node_id

              # Register message input port
              self.message_port_register_in(gr.pmt.intern("in"))
              self.set_msg_handler(gr.pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              """Handles incoming messages and sends them over UDP."""
              try:
                  msg = pmt.to_python(msg)
                  mac_tx = [msg[0]['address 2'], msg[0]['address 1'], msg[0]['address 3']]
                  if "e8:94:f6:09:ae:bd" in mac_tx:
                      seconds = msg[0]['wifi_toa'][0]
                      nanoseconds = msg[0]['wifi_toa'][1]

                      # Create the dictionary message
                      message = {
                          "node": self.node_id,
                          "wifi_toa_sec": seconds,  # Integer part (seconds)
                          "wifi_toa_nsec": nanoseconds,  # Fractional part (nanoseconds)
                          "mac": mac_tx,
                          "ssid": msg[0]['ssid'],
                          "sequence number": msg[0]['sequence number'],
                          "snr": msg[0]['snr'],
                          "subtype": msg[0]['subtype'],
                          "type": msg[0]['type'],
                      }
                      
                      # Send the serialized message over UDP
                      print(f"Sending message: {message} to {self.host}:{self.port}")
                      self.sock.sendto(str(message).encode('utf-8'), (self.host, self.port))
              except Exception as e:
                  print(f"Error sending message: {e}")
    host: udp_ip_address
    node_id: '0'
    port: udp_port
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import pmt
      import numpy as np
      from gnuradio import gr

      import datetime



      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, format_timestamp=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Print DroneID Packets',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.format_timestamp = int(format_timestamp)
              self.message_port_register_in(gr.pmt.intern("in"))
              self.set_msg_handler(gr.pmt.intern("in"), self.handle_msg)
              self.id = 0
              
          def handle_msg(self, msg):
              msg = pmt.to_python(msg)
              try:
                  mac_tx = [msg[0]['address 2'], msg[0]['address 1'], msg[0]['address 3']]
                  if "e8:94:f6:09:ae:bd" in mac_tx:
                      if self.format_timestamp == 1:
                          # timestamp = msg[0]['wifi_toa']
                          # seconds = int(timestamp)  # Extract seconds
                          # nanoseconds = int((timestamp - seconds) * 1e9)  # Extract nanoseconds

                          seconds = msg[0]['wifi_toa'][0]
                          nanoseconds = msg[0]['wifi_toa'][1]
                          
                          formatted_time = f"{datetime.datetime.utcfromtimestamp(seconds).strftime('%Y-%m-%d %H:%M:%S')}.{nanoseconds:09d}"
                          # timestamp = msg[0]['wifi_toa']
                          # dt = datetime.datetime.utcfromtimestamp(timestamp)
                          # formatted_time = dt.strftime('%Y-%m-%d %H:%M:%S.%f')  # Microseconds included

                          print(f"[{self.id}] DroneID Packet found: {formatted_time} - {msg[1]} {mac_tx}")
                      else:
                          print (f"[{self.id}] DroneID Packet found: {msg[0]['wifi_toa']:.9f} - {msg[1]} {mac_tx}")
                      self.id = self.id + 1
              except Exception as e:
                  print(f"Error printing message: {e}")
    format_timestamp: '1'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {state: disabled}
- name: freq
  id: parameter
  parameters:
    label: Center frequency
    short_id: f
    type: intx
    value: '2412000000'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: node
  id: parameter
  parameters:
    label: ID of receiver node
    short_id: n
    type: intx
    value: '0'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 48*10
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: udp_ip_address
  id: parameter
  parameters:
    label: IP address of udp receiver
    short_id: a
    type: str
    value: 127.0.0.1
  states: {}
- name: udp_port
  id: parameter
  parameters:
    label: Port of udp receiver
    short_id: p
    type: intx
    value: '5005'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_source0: gpsdo
    dev_addr: ''
    dev_args: '""'
    gain0: gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: gps_time
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_meta_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_tag_debug_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', blocks_tag_debug_0_0, '0']
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_11_parse_mac_0, out, blocks_message_debug_0, print]
- [ieee802_11_parse_mac_0, out, epy_block_1, in]
- [ieee802_11_parse_mac_0, out, epy_block_2, in]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_long_0, '0', blocks_tag_debug_1, '0']
- [ieee802_11_sync_long_0, '0', epy_block_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_tag_debug_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0-rc1
